Commit message: 6DOF panda is prepared

File: urdf/panda_fixed.urdf (robot description, URDF)
Before this commit: robot panda, 13 links, 12 joints
Joints:
- joint panda_joint7: limit lower=-2.9671 upper=2.9671 effort=12 velocity=2.6100 -> (none); type revolute -> fixed
